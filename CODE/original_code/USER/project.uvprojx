# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FIRMWARE\ST_Firmware\inc;..\FIRMWARE\MY_Firmware\system;..\FIRMWARE\MY_Firmware\global;..\FIRMWARE\MY_Firmware\include\driver;..\FIRMWARE\MY_Firmware\include\system;..\SDK\sdk_include;..\MODULE\mod_include;..\SDK;..\u8g2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group GLOBAL
    ../FIRMWARE/MY_Firmware/global/: param.h param.c
  group SDK
    ../SDK/: irq_handler.c sdk_motion.c sdk_menu.c sdk_oled.c Delay.c Key.c
  group MODULE
    ../MODULE/: mod_init.c mod_oled.c mod_at24cxx.c mod_w25qxx.c mod_mpu6050.c mod_oled_font.c mod_u8g2_port.c
  group SYSTEM
    ../FIRMWARE/MY_Firmware/system/: sys.c sys_i2c.c sys_spi.c sys_key.c sys_encoder.c sys_servo.c
  group DRIVER
    ../FIRMWARE/MY_Firmware/driver/: drv_led.c drv_key.c drv_systick.c drv_usart1.c drv_i2c.c drv_spi.c drv_exti.c drv_timer.c drv_pwm.c drv_capture.c drv_encoder.c
  group INCLUDE
    ../FIRMWARE/MY_Firmware/include/system/: sys.h sys_i2c.h sys_spi.h sys_key.h sys_encoder.h sys_servo.h
    ../FIRMWARE/MY_Firmware/include/driver/: drv_led.h drv_key.h drv_systick.h drv_usart1.h drv_i2c.h drv_spi.h drv_exti.h drv_timer.h drv_pwm.h drv_capture.h drv_encoder.h
  group ST_FIRMWARE
    ../FIRMWARE/ST_Firmware/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group U8G2
    ../U8G2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
